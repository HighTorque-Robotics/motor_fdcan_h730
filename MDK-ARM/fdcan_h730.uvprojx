# Keil uVision project fdcan_h730.uvprojx, settings and files
target fdcan_h730 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H730VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: fdcan_h730 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32H730xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../App/led;../App/my_fdcan;../App/debug_print;../src/livelybot_fdcan;../src/convert;../src/motor_control;../src/motor;../src/motor_many;../test/test_motor;../test/test_motor_many;../src/motor_config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h730xx.s
  group App
    ../App/my_fdcan/: my_fdcan.c
    ../App/led/: led.c
    ../App/debug_print/: debug_print.c
  group Src
    ../src/motor/: motor.c
    ../src/livelybot_fdcan/: livelybot_fdcan.c
    ../src/convert/: convert.c
    ../src/motor_control/: motor_control.c
    ../src/motor_many/: motor_many.c
    ../src/motor_config/: motor_config.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fdcan.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Test
    ../test/test_motor/: test_motor.c
    ../test/test_motor_many/: test_motor_many.c
software components: CMSIS:CORE 5.4.0
